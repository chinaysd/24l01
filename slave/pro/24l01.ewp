# IAR project 24l01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..\app; ..\bsp; ..\lib\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 24l01.srec
  ILINK.IlinkOutputFile: 24l01.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../app/: app.c main.c stm8s_it.c
  group bsp
    ../bsp/: NRF24L01.c oled.c TimeOut.c
  group lib
    ../lib/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim4.c stm8s_uart1.c
